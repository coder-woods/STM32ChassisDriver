# Keil uVision project STM32ChassisDriver.uvproj, settings and files
target STM32ChassisDriver (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32ChassisDriver +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\PWM;..\FWLIB\inc;..\HARDWARE\RS485;..\HARDWARE\RS232;..\SOFTWARE\PROTOCOL;..\HARDWARE\TIMER;..\HARDWARE\IWDG;..\HARDWARE\EXTI;..\HARDWARE\ADC;..\HARDWARE\CAN;..\USMART;..\HARDWARE\SPI;..\HARDWARE\IIC;..\SOFTWARE\FEEDBACK;..\SOFTWARE\MOTOR;..\SOFTWARE\BOTARM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/RS232/: rs232.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/SPI/: spi.c
  group SOFTWARE
    ../SOFTWARE/protocol/: protocol.c
    ../SOFTWARE/FEEDBACK/: feedback.c
    ../SOFTWARE/MOTOR/: motor.c
    ../SOFTWARE/BOTARM/: botarm.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_fsmc.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
